
require kernel-module-unipi.inc

# For backwards compatibility
PROVIDES += "kernel-module-unipi-mfds"

S = "${UNPACKDIR}/${BP}/modules/unipi-mfd"

