
require kernel-module-unipi.inc

# For backwards compatibility
PROVIDES += "kernel-module-unipi-rfkill"

S = "${UNPACKDIR}/${BP}/modules/unipi-rfkill"
